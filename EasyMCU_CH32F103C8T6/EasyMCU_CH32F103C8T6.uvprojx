# Keil uVision project EasyMCU_CH32F103C8T6.uvprojx, settings and files
target EasyMCU_CH32F103C8T6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH32F103C8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F103C8T6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: .\SRC\CMSIS;.\SRC\Debug;.\SRC\Startup;.\SRC\StdPeriphDriver\inc;.\SRC\StdPeriphDriver\src;.\user;..\SimulateCDC;.\user\UART;.\user\HUSB_Device;.\user\USBLIB\CONFIG;.\user\USBLIB\USB-Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: ch32f10x_it.c Main.c system_ch32f10x.c usbd_compatibility_hid.c
  group uart
    ./user/UART/: UART.c
  group husb_device
    ./user/HUSB_Device/: ch32f10x_usbfs_device.c husb_desc.c
  group startup
    SRC/Startup/: startup_ch32f10x.s
  group core
    SRC/CMSIS/: core_cm3.c
  group debug
    SRC/Debug/: debug.c
  group peripheral
    ./SRC/StdPeriphDriver/src/: ch32f10x_adc.c ch32f10x_bkp.c ch32f10x_can.c ch32f10x_crc.c ch32f10x_dac.c ch32f10x_dbgmcu.c ch32f10x_dma.c ch32f10x_exti.c ch32f10x_flash.c ch32f10x_gpio.c ch32f10x_i2c.c ch32f10x_iwdg.c ch32f10x_misc.c ch32f10x_pwr.c ch32f10x_rcc.c ch32f10x_rtc.c ch32f10x_spi.c ch32f10x_tim.c ch32f10x_usart.c ch32f10x_usb.c ch32f10x_wwdg.c
  group usbcore
    ./user/USBLIB/USB-Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group usbconfig
    ./user/USBLIB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
